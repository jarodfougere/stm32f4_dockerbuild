# IAR project rimot-lowpower-sensorboard.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411VE ST STM32F411VE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F4xx; STM32F411xE; MCU_APP
  ICCARM.PreInclude: ..\Sources\preinclude.h
  ICCARM.CCIncludePath2: ..\Sources\Device; ..\Sources\Device\Drivers\CMSIS; ..\Sources\Device\Drivers\CMSIS\Core\Include; ..\Sources\Device\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\Sources\Device\Drivers\CMSIS\Include; ..\Sources\Device\Drivers\STM32F4xx_HAL_Driver\Inc; ..\Sources\Device\Drivers\STM32F4xx_HAL_Driver\Inc\Legacy; ..\Sources\Device\Startup; ..\Sources\Device\Drivers\STM32F4xx_HAL_Driver; ..\Sources\Device\Drivers\STM32_USB_Device_Library\Core\Inc; ..\Sources\Application\Tasks\Inc; ..\Sources\Application; ..\Sources\Application\Rimot Device; ..\Sources\Application\Rimot Device\Inc; ..\Sources\Device\Drivers\STM32_USB_Device_Library\Core\Inc; ..\Sources\Device\Drivers\STM32_USB_Device_Library\Class\CDC\Inc; ..\Sources\Device\Drivers\STM32_USB_Device_Library\Class\DFU\Inc; ..\Sources\Device\Drivers\STM32_USB_Device_Library\Core; ..\Sources\Device\Drivers\STM32_USB_Device_Library\Class; ..\Sources\Device\Drivers\STM32_USB_Device_Library; ..\Sources\Middleware\Abstractions; ..\Sources\Middleware\Abstractions\Inc; ..\Sources\Middleware\Interfaces; ..\Sources\Middleware\Interfaces\Inc; ..\Sources\Middleware\USB; ..\Sources\Middleware\USB\Inc; ..\Sources\Middleware; ..\Sources\Application\Tasks
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: most_recent_build.hex
  ILINK.IlinkOutputFile: rimot-lowpower-sensorboard.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../Sources/Application/: main.c
  group Application/Tasks
    ../Sources/Application/Tasks/Src/: analytics_task.c battery_task.c digital_input_task.c humidity_task.c motion_task.c relay_task.c rf_task.c serial_task.c system_task.c temperature_task.c
    ../Sources/Application/Tasks/: tasks.c
  group Application/VirtualDevice
    ../Sources/Application/Rimot Device/Src/: rimot_device.c rimot_device_config.c
  group Device/Drivers/CMSIS
    ../Sources/Device/Drivers/CMSIS/Device/ST/STM32F4xx/Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c
  group Device/Drivers/HAL
    ../Sources/Device/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Device/Drivers/USB
    ../Sources/Device/Drivers/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Sources/Device/Drivers/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Sources/Device/Drivers/STM32_USB_Device_Library/Class/DFU/Src/: usbd_dfu.c
  group Device/Startup
    ../Sources/Device/Startup/IAR/: stm32f411xe.s
  group Middleware
    ../Sources/Middleware/: middleware_core.c
  group Middleware/Abstractions
    ../Sources/Middleware/Abstractions/Src/: analog_measurements.c leds.c mcupin.c mjson.c
  group Middleware/Interfaces
    ../Sources/Middleware/Interfaces/Src/: gpio_interface.c humidity_interface.c payloads.c rf_interface.c system_config.c temperature_interface.c
  group Middleware/USB
    ../Sources/Middleware/USB/Src/: usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c
